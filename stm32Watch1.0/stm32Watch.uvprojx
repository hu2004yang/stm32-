# Keil uVision project stm32Watch.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 01_led_register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Start;.\User;.\system;.\Hardware;.\App;.\Game
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ./User/: main.c
  group system
    ./system/: Delay.c Timer.c MyRTC.c
  group Hardware
    ./Hardware/: key.c LED.c OLED.c OLED_Data.c adc.c i2c.c
  group App
    ./App/: menu.c SetTime.c StopWatch.c FlashLight.c game.c MPU6050.c Gradienter.c
  group Game
    ./Game/: Dino.c
