# Keil uVision project CS-LORA.uvprojx, settings and files
target CS-LORA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CS-LORA +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\HARDWARE\delay;..\HARDWARE\usart;..\HARDWARE\OLED;..\HARDWARE\Key;..\HARDWARE\dht11;..\HARDWARE\ADC;..\HARDWARE\ESP8266;..\HARDWARE\GeneralTim;..\HARDWARE\step_motor;..\HARDWARE\HC-SR04;..\HARDWARE\Infrared;..\HARDWARE\SG90;..\HARDWARE\A7680C;..\HARDWARE\EC800;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\MPU6050;..\HARDWARE\IO;..\HARDWARE\BC26;..\HARDWARE\CS_Lora;..\HARDWARE\led;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_iwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
  group DOC
    ../Doc/: readme.txt
  group HARDWARE
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/usart/: bsp_usart.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/GeneralTim/: bsp_GeneralTim.c
    ../HARDWARE/CS_Lora/: CS_Lora.c
    ../HARDWARE/led/: bsp_led.c
    ../HARDWARE/IO/: bsp_io.c
    ../HARDWARE/ESP8266/: bsp_esp8266.c bsp_esp8266_test.c
  group App
    ../APP/: Weather.c
